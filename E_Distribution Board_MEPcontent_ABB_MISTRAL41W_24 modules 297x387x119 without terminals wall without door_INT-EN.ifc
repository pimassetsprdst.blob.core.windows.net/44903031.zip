Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-22T11:08:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 22 11:08:38 2021 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\{4AD13946-C459-4449-AE57-B388A99699F0}\ifc * Database version: 5507 * Database creation date: Wed Sep 22 11:08:38 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 22 11:08:38 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 22 11:08:38 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcElectricDistributionBoard: 24 modules 297x387x119 without terminals wall without door, E_Distribution Board_MEPcontent_ABB_MISTRAL41W_24M-36M_INT-EN:24 modules 297x387x119 without terminals wall without door:46727
In: Level 1
Type - Material: Color RAL 7035
Type - Dimensions - Depth: 119 mm; Height: 387 mm; Width: 297 mm
Type - Electrical - Loads - Max Dissipation Power: 30 W; Maximum Current: 63 A
Type - Electrical Engineering - Nominal Voltage: 0 V
Type - Identity Data - Article Description: MISTRAL41W wall without door 24M; Article Type: 24 modules 297x387x119 without terminals wall without door; Base Family Version: 12.32; Cable Entry Finish: Smooth; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Consumer units MISTRAL41W; EMCS Version: 4.0; ETIM Article Class: EC000214; Extractable Frame: Yes; Family Version: 12.31; GTIN: 8712507119421; GWT: 650°C; Halogen Free: Yes; Installation Temperature: -15°C/+60°C; IP Rating: IP41; Knockout Resistance To Mechanical Impacts: IK08; Manufacturer: ABB; Manufacturer Art. No.: 1SPE007717F0500; Manufacturer URL: https://new.abb.com/low-voltage/launches/mistral-41; MEPcontent Class: DISTRIBUTION_BOARD; Model: 41W; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: MISTRAL41W; Protection Class: II; Resistance To Heat: BPT 70°C; Resistance To Mechanical Impacts: IK08; Revit Version: 2019; Type Name: 24 modules 297x387x119 without terminals wall without door; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - White: Color RAL 7035
Type - Other - Category: Electrical Equipment; Base Horizontal Safe Mounting Box: 129 mm; Base Vertical Safe Mounting Box: 179.2 mm; Cover Thickness: 32 mm; Door: Opaque; Door Thickness: 27 mm; Door Width: 291.8 mm; Family Name: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_24M-36M_INT-EN; Front Profile Offset: 67 mm; Handle Opaque: yes; Handle Plan: 15.9 mm; Handle Transparent: yes; Height Safe: 387 mm; Horizontal Open Panel: 234 mm; Logo Offset Plan: 13.9 mm; No Door: No Door; Offset Front Void: 13 mm; Opaque: yes; Opaque Door: Opaque; Radius: 816 mm; Thickness Panel: 4 mm; Top Horizontal Safe Mounting Box: 140.1 mm; Top Vertical Safe Mounting Box: 182 mm; Transparent: yes; Transparent Door: Transparent; Vertical Open Panel: 46 mm; Void Handle Plan: 21 mm; Void Right Dimension: 9.5 mm; Width Front: 291 mm
Type - Visibility - Door Visibility: no; Handle Visibility: yes
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 0.702901 m2; Volume: 0.0130349 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 0 V/1-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Power: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 1
Other - Family: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_24M-36M_INT-EN: 24 modules 297x387x119 without terminals wall without door; Family and Type: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_24M-36M_INT-EN: 24 modules 297x387x119 without terminals wall without door; Left Clearance: 291.8 mm; No Door: no; Opaque Door: yes; Reversible Cover: 180 deg; Right Clearance: 0 mm; Service Area Safe: no; Transparent Door: no; Type: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_24M-36M_INT-EN: 24 modules 297x387x119 without terminals wall without door; Type Id: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_24M-36M_INT-EN: 24 modules 297x387x119 without terminals wall without door
Phasing - Phase Created: New Construction
Visibility - Reverse Door Mounting: no; Show Service Area: no
