Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-22T11:09:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 22 11:09:06 2021 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\{3FF7DE23-4E43-432C-9D6E-84B2A121E93E}\ifc * Database version: 5507 * Database creation date: Wed Sep 22 11:09:05 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 22 11:09:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 22 11:09:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcElectricDistributionBoard: 18 modules 387x262x119 without terminals wall with transparent door, E_Distribution Board_MEPcontent_ABB_MISTRAL41W_2M-18M_INT-EN:18 modules 387x262x119 without terminals wall with transparent door:52206
In: Level 1
Type - Material: Color RGB 066-158-193, Color RAL 7035
Type - Dimensions - Depth: 119 mm; Height: 262 mm; Width: 387 mm
Type - Electrical - Loads - Max Dissipation Power: 30 W; Maximum Current: 63 A
Type - Electrical Engineering - Nominal Voltage: 0 V
Type - Identity Data - Article Description: Consumer units MISTRAL41W wall with transparent door 18M; Article Type: 18 modules 387x262x119 without terminals wall with transparent door; Base Family Version: 12.32; Cable Entry Finish: Smooth; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Consumer units MISTRAL41W; EMCS Version: 4.0; ETIM Article Class: EC000214; Extractable Frame: Yes; Family Version: 11.18; GTIN: 8712507119537; GWT: 650°C; Halogen Free: Yes; Installation Temperature: -15°C/+60°C; IP Rating: IP41; Knockout Resistance To Mechanical Impacts: IK08; Manufacturer: ABB; Manufacturer Art. No.: 1SPE007717F0820; Manufacturer URL: https://new.abb.com/low-voltage/launches/mistral-41; MEPcontent Class: DISTRIBUTION_BOARD; Model: 41W; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: MISTRAL41W; Protection Class: II; Resistance To Heat: BPT 70°C; Resistance To Mechanical Impacts: IK08; Revit Version: 2019; Type Name: 18 modules 387x262x119 without terminals wall with transparent door; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - White: Color RAL 7035
Type - Other - Category: Electrical Equipment; Base Horizontal Safe Mounting Box: 129 mm; Base Vertical Safe Mounting Box: 179.2 mm; Cover Thickness: 32 mm; Depth From Cover: 419 mm; Door: Opaque; Door Thickness: 27 mm; Door Width: 381.8 mm; Family Name: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_2M-18M_INT-EN; Front Profile Offset: 67 mm; Handle Opaque: no; Handle Plan: 18.3 mm; Handle Transaparent: yes; Height Safe: 262 mm; Horizontal Open Panel: 324 mm; Logo Offset Plan: 13.8 mm; No Door: No Door; Offset Front Void: 13.1 mm; Opaque: no; Opaque Door: Opaque; Radius: 1381 mm; Service Length: 92 mm; Thickness Panel: 4 mm; Top Horizontal Safe Mounting Box: 140.1 mm; Top Vertical Safe Mounting Box: 182 mm; Transparent: yes; Transparent Door: Transparent; Vertical Open Panel: 46 mm; Void Handle Plan: 24 mm; Void Right Dimension: 11.1 mm; Width Front: 381 mm
Type - Visibility - Door Visibility: yes; Handle Visibility: yes
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 0.769175 m2; Volume: 0.0115235 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 0 V/1-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Power: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 1
Other - Family: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_2M-18M_INT-EN: 18 modules 387x262x119 without terminals wall with transparent door; Family and Type: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_2M-18M_INT-EN: 18 modules 387x262x119 without terminals wall with transparent door; Left Clearance: 381.8 mm; No Door: no; Opaque Door: yes; Reversible Cover: 180 deg; Right Clearance: 0 mm; Service Area Safe: no; Transparent Door: no; Type: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_2M-18M_INT-EN: 18 modules 387x262x119 without terminals wall with transparent door; Type Id: E_Distribution Board_MEPcontent_ABB_MISTRAL41W_2M-18M_INT-EN: 18 modules 387x262x119 without terminals wall with transparent door
Phasing - Phase Created: New Construction
Visibility - Reverse Door Mounting: no; Show Service Area: no
